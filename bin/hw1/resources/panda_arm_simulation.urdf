Commit message: added correction terms for gravity and mass when payload is added, sort of works

File: bin/hw1/resources/panda_arm_simulation.urdf (robot description, URDF)
Before this commit: robot panda, 8 links, 7 joints
Links:
- link link7: mass 0.5 -> 3.0
